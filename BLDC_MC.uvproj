# Keil uVision project BLDC_MC.uvproj, settings and files
target Fu68xx_MC (MCS-51)
  device: FU68XX Fortior Tech
  cpu: IRAM(0-0xFF) CLOCK(24000000)
  output: Ftech_BLDC +hex
  c flags: Optimize=8
  c include: .\Library\Include;.\User\Include
  link misc: REMOVEUNUSED
  group fu68xx_Driver
    ./Library/Source/: FU68xx_System.LIB
    ./User/Source/: Ftech_BLDC2.5.3.LIB
  group User
    ./User/Include/: sys_conf.h user_conf.h Function.h
    ./User/Source/: Interrupt.c main.c MC_init.c MC_UserInterface_layer.c MC_MotorFunction_layer.c MC_MotorCotrol_layer.c MC_MotorDriver_layer.c
  group Function
    ./User/Source/: MC_Key.c MC_PwmIn.c MC_Beep.c MC_Led.c
  group Hardware
    ./User/Source/: fu68xx_Sys.c fu68xx_Dmc.c fu68xx_MCadc.c fu68xx_MCamp.c fu68xx_MCcmp.c fu68xx_MCflash.c fu68xx_MChall.c fu68xx_MClpf.c fu68xx_MCmdu.c fu68xx_MCpid.c fu68xx_MCspi.c fu68xx_MCtime.c fu68xx_MCuart.c
  group Doc
    ./doc/: DebugLog.txt
